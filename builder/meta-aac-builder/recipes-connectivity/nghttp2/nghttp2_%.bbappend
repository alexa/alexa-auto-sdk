# Libraries only
EXTRA_OECMAKE_append_machine-native = "-DENABLE_LIB_ONLY=ON"