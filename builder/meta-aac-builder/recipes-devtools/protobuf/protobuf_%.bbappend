LDFLAGS_append_android = " -llog"