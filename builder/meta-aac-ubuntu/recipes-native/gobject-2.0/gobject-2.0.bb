inherit native hostnativeglibpackage
