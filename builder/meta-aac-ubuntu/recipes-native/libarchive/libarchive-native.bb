inherit native hostnativepackage

HOST_LIBRARY_NAME = "archive"
HOST_INCLUDE_NAME = "archive"