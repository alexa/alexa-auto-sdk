inherit native hostnativepackage

HOST_LIBRARY_NAME = "z"