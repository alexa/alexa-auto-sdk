FILES_SOLIBSDEV = ""
SOLIBS = ".so"