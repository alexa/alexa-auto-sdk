SUMMARY = "Alexa Automotive Core - AASB Phone Control"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://engine/include/AASB/Engine/PhoneCallController/AASBPhoneCallControllerEngineService.h;beginline=4;endline=13;md5=527e9938f0eaf4dbc8d3b17563870ae7"

DEPENDS = "aac-module-phone-control aac-module-aasb nlohmann"

inherit pkgconfig aac-module devlibsonly