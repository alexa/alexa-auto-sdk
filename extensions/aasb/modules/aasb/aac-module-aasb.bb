SUMMARY = "Alexa Automotive Core - AASB Module"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://platform/include/AACE/AASB/AASB.h;beginline=4;endline=13;md5=527e9938f0eaf4dbc8d3b17563870ae7"

DEPENDS = "aac-module-core nlohmann"

inherit pkgconfig aac-module devlibsonly