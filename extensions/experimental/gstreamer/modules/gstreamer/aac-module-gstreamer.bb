SUMMARY = "Alexa Automotive Core - GStreamer Module"
HOMEPAGE = "http://github.com/alexa"
LICENSE = "CLOSED"

DEPENDS = "avs-device-sdk aac-module-core gstreamer1.0"

inherit pkgconfig aac-module devlibsonly