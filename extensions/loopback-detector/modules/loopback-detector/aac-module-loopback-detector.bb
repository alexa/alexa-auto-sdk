SUMMARY = "Alexa Automotive Core - Loopback Detector Module"
HOMEPAGE = "http://github.com/alexa"
LICENSE = "ASL-1.0"
LIC_FILES_CHKSUM = "file://engine/src/LoopbackDetector.h;beginline=6;endline=15;md5=fe6d8774bb4ab1279b878744957fa447" 

DEPENDS = "avs-device-sdk aac-module-core aac-module-alexa"

inherit aac-module devlibsonly
