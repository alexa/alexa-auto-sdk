SUMMARY = "Alexa Automotive Core - Address Book Module"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://platform/include/AACE/AddressBook/AddressBook.h;beginline=2;endline=13;md5=f5a0c55dc26282d9074749804fb96471"

DEPENDS = "aac-module-core aac-module-alexa"

inherit aac-module devlibsonly
