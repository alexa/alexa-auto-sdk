SUMMARY = "Alexa Automotive Core - Alexa Module"
HOMEPAGE = "http://github.com/alexa"
LICENSE = "CLOSED"

DEPENDS = "avs-device-sdk aac-module-core"

PV = "0.99.0"

inherit aac-module