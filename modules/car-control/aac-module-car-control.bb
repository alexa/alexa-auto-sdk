SUMMARY = "Alexa Auto SDK - Car Control Module"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://platform/include/AACE/CarControl/CarControl.h;beginline=2;endline=13;md5=f5a0c55dc26282d9074749804fb96471"

DEPENDS = "aac-module-core aac-module-alexa nlohmann"

inherit aac-module devlibsonly  