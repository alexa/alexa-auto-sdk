SUMMARY = "Alexa Automotive Core - Connectivity Module"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://platform/include/AACE/Connectivity/AlexaConnectivity.h;beginline=4;endline=13;md5=527e9938f0eaf4dbc8d3b17563870ae7"

DEPENDS = "avs-device-sdk aac-module-core aac-module-alexa nlohmann"

inherit aac-module devlibsonly
