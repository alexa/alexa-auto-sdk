SUMMARY = "Alexa Automotive Core - ContactUploader Module"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://platform/include/AACE/ContactUploader/ContactUploader.h;beginline=2;endline=13;md5=1d6dd180aaf536a4d19e562dd6f6fbdc"

DEPENDS = "aac-module-core aac-module-alexa"

inherit aac-module devlibsonly