SUMMARY = "Alexa Automotive Core - Navigation Module"
HOMEPAGE = "http://github.com/alexa"
LICENSE = "CLOSED"

DEPENDS = "aac-module-core aac-module-alexa"

PV = "0.99.0"

inherit aac-module