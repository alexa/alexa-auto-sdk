SUMMARY = "Alexa Automotive Core - PhoneControl Module"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://platform/include/AACE/PhoneCallController/PhoneCallController.h;beginline=2;endline=13;md5=e24dab4dc71d22b64c3479728f206e46"

DEPENDS = "aac-module-core aac-module-alexa"

inherit aac-module devlibsonly