IMAGE_INSTALL += "aac-sample-audio"